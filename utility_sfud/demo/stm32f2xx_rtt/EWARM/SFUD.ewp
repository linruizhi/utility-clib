# IAR project SFUD.ewp, settings and files
configuration STM32F205RG (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RG ST STM32F205RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_FULL_ASSERT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\app\inc; ..\components\rtt_uart; ..\components\rtt_spi; ..\components\others; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\RT-Thread-2.1.0\include; ..\RT-Thread-2.1.0\components\drivers\include; ..\RT-Thread-2.1.0\components\drivers\include\drivers; ..\RT-Thread-2.1.0\components\drivers\spi; ..\RT-Thread-2.1.0\components\drivers\spi\sfud\inc; ..\RT-Thread-2.1.0\components\finsh; ..\RT-Thread-2.1.0\components\utilities\ymodem; ..\components\sfud\inc; ..\..\..\sfud\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SFUD.bin
  ILINK.IlinkOutputFile: SFUD.out
  ILINK.IlinkIcfFile: ..\components\others\stm32f205xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/src/: app.c app_task.c stm32f2xx_it.c user_finsh_cmd.c
    ../app/inc/: rtconfig.h
  group components/others
    ../components/others/: bsp.c utils.c
  group components/rtt_spi
    ../components/rtt_spi/: spi_master.c
  group components/rtt_uart
    ../components/rtt_uart/: usart.c
  group components/sfud/src
    ../../../sfud/src/: sfud.c sfud_sfdp.c
  group libs/cmsis
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group libs/std_periph_driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group RT-Thread-2.1.0/drivers/serial
    ../RT-Thread-2.1.0/components/drivers/serial/: serial.c
  group RT-Thread-2.1.0/drivers/spi
    ../RT-Thread-2.1.0/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group RT-Thread-2.1.0/drivers/src
    ../RT-Thread-2.1.0/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group RT-Thread-2.1.0/finsh
    ../RT-Thread-2.1.0/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group RT-Thread-2.1.0/kernel
    ../RT-Thread-2.1.0/src/: clock.c components.c cpuusage.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread-2.1.0/libcpu
    ../RT-Thread-2.1.0/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group RT-Thread-2.1.0/ymodem
    ../RT-Thread-2.1.0/components/utilities/ymodem/: ymodem.c
